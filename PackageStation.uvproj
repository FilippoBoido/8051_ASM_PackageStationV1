# Keil uVision project PackageStation.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8253 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: PackageStation +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: PUBLIC_ACCESS.INC PUBLIC_PROCEDURES.INC PROCEDURES.a51 VARIABLES.a51 TIMERS.a51 IO.a51 CONSTANTS.a51 MESSAGES.a51 MAIN.a51
